# Keil uVision project CyberBalance.uvprojx, settings and files
target Target (6150000::V6.15::ARMCLANG)
  device: STM32L053C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CyberBalance +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32L053xx,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,USE_HAL_DRIVER
  c include: .\Inc;..\FWLIB\Inc;..\CORE;..\SYSTEM\Inc;..\HARDWARE\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ./Src/: main.c stm32l0xx_it.c system_stm32l0xx.c stm32l0xx_hal_msp.c
  group FWLIB
    ../FWLIB/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_exti.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_lcd.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_rcc.c stm32l0xx_ll_usart.c stm32l0xx_ll_utils.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_adc.c
  group HARDWARE
    ../HARDWARE/Src/: bc28.c lcd.c hx711.c btn.c
  group SYSTEM
    ../SYSTEM/Src/: usart.c sys.c adc.c
  group CORE
    ../CORE/: startup_stm32l053xx.s
